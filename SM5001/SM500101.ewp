# IAR project SM500101.ewp, settings and files
configuration Build (ARM, debug)
  General.OGChipSelectEditMenu: GD32F303xC GD GD32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; _ANYID_GD32_; _ANYID_HSE12P00_; _ANYID_SM5001_; _ANYID_BOOT_GD32_; _ANYID_SM500100_
  ICCARM.CCIncludePath2: ..\; ..\inc; E:\AnyID\AnyID_Embedded\V1.1.0\STM32_lib_V3.3\startup; E:\AnyID\AnyID_Embedded\V1.1.0\STM32_lib_V3.3\inc; E:\AnyID\AnyID_Embedded\V1.1.0\AnyID_lib_V1.1.0\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SM500101.hex
  ILINK.IlinkOutputFile: SM500101.out
  ILINK.IlinkIcfFile: GD32F303xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../AnyID_Embedded/V1.1.0/STM32_lib_V3.3/startup/: system_stm32f10x.c
  group EWARMv5
    ../../../../AnyID_Embedded/V1.1.0/STM32_lib_V3.3/startup/: startup_stm32f10x_hd.s
  group Main
    ../: main.c stm32f10x_conf.h stm32f10x_it.c
  group StdPeriph_Driver
    ../../../../AnyID_Embedded/V1.1.0/STM32_lib_V3.3/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ../src/: AnyID_FRam.c AnyID_SM5001_AD.c AnyID_SM5001_AD_HL.c AnyID_SM5001_Device.c Anyid_SM5001_ELECT.c Anyid_SM5001_ELECT_HL.c AnyID_SM5001_FRam.c AnyID_SM5001_FRam_HL.c AnyID_SM5001_Gate.c AnyID_SM5001_Gate_HL.c AnyID_SM5001_IO.c AnyID_SM5001_IO_HL.c AnyID_SM5001_RTC.c Anyid_SM5001_Sound.c Anyid_SM5001_Sound_HL.c AnyID_SM5001_SysCfg.c AnyID_SM5001_SysTick_HL.c AnyID_SM5001_Uart.c AnyID_SM5001_Uart_HL.c AnyID_SM5001_W232.c AnyID_SM5001_W232_HL.c Anyid_SM5001_Water.c Anyid_SM5001_Water_HL.c AnyID_SM5001_WDG_HL.c AnyID_Uart_Receive.c base64.c hmac_sha1.c md5.c
    ../../../../AnyID_Embedded/V1.1.0/AnyID_lib_V1.1.0/src/: AnyID_Stdlib.c
