<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\Boot\SM500101\Boot.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\SM500101.ewp</path>
    </project>
    <batchBuild />
</workspace>
